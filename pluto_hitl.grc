options:
  parameters:
    author: SDCS Digital Twin Team
    description: Hardware In The Loop Pluto SDR Transceiver Bridge for SDCS Digital Twin
    generate_options: qt_gui
    id: pluto_hitl
    output_language: python
    title: SDCS Digital Twin — Pluto HITL
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: Baseband sample rate matching Python twin (1 MSPS)
    value: '1000000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: Shared LO frequency for TX and RX (2.4 GHz ISM)
    value: '2400000000'
  states: {}
- name: tx_atten
  id: variable
  parameters:
    comment: TX Hardware attenuation in dB (0 to 89.75 dB)
    value: '30'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    comment: RX Hardware manual gain in dB (0 to 73 dB)
    value: '40'
  states: {}
- name: rf_bw
  id: variable
  parameters:
    comment: Pluto analog filter RF bandwidth (1.5 MHz)
    value: '1500000'
  states: {}
- name: pluto_uri
  id: variable
  parameters:
    comment: Pluto SDR URI dynamically detected (USB or IP)
    value: iio.get_pluto_uri()
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: 127.0.0.1
    comment: Exposes set_center_freq, set_tx_atten, set_rx_gain, set_samp_rate, set_rf_bw
    port: '8090'
  states: {}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: tcp://127.0.0.1:5556
    comment: Pulls complex baseband + Digital IF samples from Python backend
    timeout: '-1'
    type: complex
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_atten
    bandwidth: rf_bw
    buffer_size: '8192'
    comment: Pluto RF Transmitter
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: center_freq
    samplerate: samp_rate
    type: fc32
    uri: pluto_uri
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: rf_bw
    bbdc: 'True'
    buffer_size: '8192'
    comment: Pluto RF Receiver (Same LO as TX)
    filter_source: '''Auto'''
    frequency: center_freq
    gain1: '''manual'''
    len_tag_key: ''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: pluto_uri
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:5555
    bind: 'False'
    comment: Pushes full complex IQ baseband to Python backend
    timeout: '100'
    type: complex
  states: {}

connections:
- [zeromq_pull_source_0, '0', iio_pluto_sink_0, '0']
- [iio_pluto_source_0, '0', zeromq_push_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
